# Keil uVision project LED.uvprojx, settings and files
target LED (ARM-ADS)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\HARDWARE\BTN7971;..\HARDWARE\PID;..\HARDWARE\LedBuz;..\HARDWARE\Mymath;.\include;..\HARDWARE\OLED;..\HARDWARE\ENCODER;..\FREECARS;..\HARDWARE\CONTROL;..\HARDWARE\SSI4096;..\HARDWARE\TIMER;..\HARDWARE\freecars;..\HARDWARE\JY901;..\HARDWARE\CTRL
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/BTN7971/: btn7971.c
    ../HARDWARE/PID/: pid.c
    ../HARDWARE/Mymath/: MyMath.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/ENCODER/: encoder.c
    ../HARDWARE/CONTROL/: control.c
    ../HARDWARE/SSI4096/: SSI4096.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/JY901/: JY901_uart.c
    ../HARDWARE/CTRL/: mynvic.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c
  group README
    ../: readme.txt
  group freecars
    ../HARDWARE/freecars/: FreeCars_isr.c FreeCars_uart.c
